
PACKAGES = ""

do_build[recrdeptask] = "do_build"

INHIBIT_DEFAULT_DEPS = "1"
