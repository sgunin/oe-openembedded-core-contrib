require python-async.inc

inherit setuptools3
