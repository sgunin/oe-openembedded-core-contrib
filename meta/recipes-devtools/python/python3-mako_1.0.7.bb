require python-mako.inc
inherit setuptools3
