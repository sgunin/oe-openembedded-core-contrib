require python-six.inc
inherit setuptools3
