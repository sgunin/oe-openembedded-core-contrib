require python-gitdb.inc

inherit distutils3
