require python-smmap.inc

inherit setuptools3
