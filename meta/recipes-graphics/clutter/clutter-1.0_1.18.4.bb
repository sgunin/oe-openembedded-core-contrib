require clutter-1.0.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=4fbd65380cdd255951079008b364516c"

SRC_URI[archive.md5sum] = "f4f37216a9278defb50b721c8f8ff583"
SRC_URI[archive.sha256sum] = "4eea1015cd6d4b4945cb5d4a60e52275b0d70e13852d6d99c9abc0cd4deeb60c"

SRC_URI += "file://install-examples.patch"
