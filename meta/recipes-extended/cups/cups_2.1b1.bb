require cups.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=6c5a350596fba02754bd96eb6df3afd0"

SRC_URI[md5sum] = "12e37ca320f46467759e9440ffad07e9"
SRC_URI[sha256sum] = "ffc7620e7dcd8412af3ff2c3da74c56d5dcbb335bf79b787bed039fe1918aee1"
